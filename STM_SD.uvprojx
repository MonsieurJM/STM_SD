# Keil uVision project STM_SD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L433CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM_SD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L433CCTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L433CCTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, File System:CORE 6.14.4, File System:Drive:Memory Card 6.14.4, CMSIS Driver:SPI 1.4.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:STM32Cube HAL:SPI 1.13.0, Device:STM32Cube HAL:TIM 1.13.0, Device:Startup 1.3.1
